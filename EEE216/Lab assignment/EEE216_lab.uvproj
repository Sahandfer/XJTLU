# Keil uVision project EEE216_lab.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: EEE216_lab
  c flags: Optim=1
  group task 2
    ./: task4.s
